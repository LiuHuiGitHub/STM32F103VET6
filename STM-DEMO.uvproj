# Keil uVision project STM-DEMO.uvproj, settings and files
target STM32F103 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: DEMO
  c flags: Optim=4 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\App;.\Driver;.\FWlib\CMSIS\startup;.\FWlib\inc;.\FWlib\src;.\uCOS-II\Source;.\uCOS-II\Ports;.\USER;.\FWlib;.\uCOS-II;.\Driver\LCD_Driver;.\Driver\Touch;.\Hwa;.\System
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./USER/: main.c MyLibrary.c stm32f10x_it.c system.c
  group CMSIS
    ./FWlib/CMSIS/startup/: startup_stm32f10x_hd.s
    ./FWlib/Lib/: stm32f10x.lib
  group Driver
    ./Driver/: drive_flash.c drive_ir.c drive_e2.c drive_usart.c
    ./Driver/LCD_Driver/: drive_lcd.c
    ./Driver/Touch/: drive_touch.c
  group Hwa
    ./Hwa/: hwa_key.c
  group System
    ./System/: sys_adc.c sys_can.c sys_dac.c sys_rtc.c sys_usart.c sys_count.c sys_pwm.c
  group Notes
    ./Notes/: Notes.txt
